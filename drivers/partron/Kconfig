## drivers/partron/Kconfig
```kconfig
config DTS201A
	tristate "Partron dts201a Support"
	help
	  Partron Thermopile Sensor dts201a support.
```
